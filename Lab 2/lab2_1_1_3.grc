options:
  parameters:
    generate_options: qt_gui
    id: ece531_1_1_3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    device: iio:device1
    output: 'False'
    required_enable: 'False'
    uri: 'usb:'
  states: {state: disabled}
- name: iio_attr_source_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: out_altvoltage0_RX_LO_frequency
    device: device1
    output: 'False'
    required_enable: 'False'
    samples_per_update: '1024'
    type: '0'
    update_interval_ms: '1'
    uri: 'local:'
  states: {state: disabled}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: out_altvoltage0_RX_LO_frequency
    update_interval_ms: '1'
    value: 915e6
  states: {state: disabled}
- name: iio_device_sink_0
  id: iio_device_sink
  parameters:
    buffer_size: '32768'
    channels: '[''voltage0'', ''voltage1'']'
    cyclic: 'False'
    device: cf-ad9361-lpc
    device_phy: ad9361-phy
    interpolation: '1'
    params: '[''out_voltage0_sampling_frequency=''4000000'']'
    uri: usb:2.8.5
  states: {state: disabled}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '[''voltage0'']'
    decimation: '1'
    device: cf-ad9361-lpc
    device_phy: ad9361-phy
    params: '[''sampling_frequency=4000000'']'
    uri: usb:2.8.5
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
