options:
  parameters:
    author: gnuradio
    generate_options: qt_gui
    id: Lab2_412
    output_language: python
    title: Lab2_412
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '5'
    stop: '100'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2084000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: Tone Frequency (Hz)
    orient: Qt.Horizontal
    start: '1'
    step: '1000'
    stop: '100000'
    value: '10000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_qtgui_range_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: '2400000000'
    samplerate: samp_rate
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '2400000000'
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
