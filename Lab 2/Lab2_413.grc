options:
  parameters:
    author: gnuradio
    generate_options: qt_gui
    id: Lab2_413
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: iio_device_sink_0
  id: iio_device_sink
  parameters:
    buffer_size: '32768'
    channels: '[1]'
    cyclic: 'False'
    device_phy: ad9136-phy
    interpolation: '1'
    params: '[]'
    uri: 'local:'
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '[]'
    decimation: '1'
    device: iio:device1
    device_phy: ad9136-phy
    params: '[]'
    uri: 'local:'
  states: {}

connections:
- [iio_device_source_0, '0', iio_device_sink_0, '0']

metadata:
  file_format: 1
